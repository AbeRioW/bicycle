# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\app;.\bsp
  group APP
    ./app/: main.c
  group BSP
    ./bsp/: lcd.c ds3231.c uart.c adc0832.c config.c ui.c DHT11.c
